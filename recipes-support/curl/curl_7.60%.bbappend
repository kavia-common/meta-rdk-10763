FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://CVE-2021-22924_7.60.0_fix.patch \
                 "

